FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://ares.cfg"
# SRC_URI += "file://*.patch"
