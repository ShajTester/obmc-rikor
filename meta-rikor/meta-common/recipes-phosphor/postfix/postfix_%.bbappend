
FILESEXTRAPATHS_prepend_ares := "${THISDIR}/${PN}:"
SRC_URI += "file://main.cf"

