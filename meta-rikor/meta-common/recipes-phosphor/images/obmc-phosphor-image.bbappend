# OBMC_IMAGE_EXTRA_INSTALL_append_ares = " mboxd"
IMAGE_INSTALL += "phosphor-webui"
IMAGE_INSTALL += "phosphor-mapper"
IMAGE_INSTALL += "ares-network"
# IMAGE_INSTALL_append = " phosphor-hwmon "
# IMAGE_INSTALL_append = " obmc-control-chassis "

IMAGE_INSTALL += "libgpio"
IMAGE_INSTALL += "rikgpio"
IMAGE_INSTALL += "rikbtnd"
IMAGE_INSTALL += "rikfans"
IMAGE_INSTALL += "ledblink-lt"
# IMAGE_INSTALL += "identifier"
# IMAGE_INSTALL += "ddiag"


