FILESEXTRAPATHS_prepend_germes := "${THISDIR}/${PN}:"
SRC_URI += "file://germes.cfg"
SRC_URI += "file://*.patch"
