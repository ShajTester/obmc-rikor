FILESEXTRAPATHS_prepend_ares := "${THISDIR}/${PN}:"
