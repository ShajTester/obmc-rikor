
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://src/conf.json"



