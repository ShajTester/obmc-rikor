KBRANCH ?= "pilot4_initial"
LINUX_VERSION ?= "4.4.33"

SRCREV="cc45fae33db4960b74f6b1059e5cba315c6d6030"

require linux-aspeed.inc

