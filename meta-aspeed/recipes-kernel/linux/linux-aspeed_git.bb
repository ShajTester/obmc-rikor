KBRANCH ?= "aspeed-dev-v5.1"
LINUX_VERSION ?= "5.1.3"

SRCREV="e62afc21ca2925281994f1f79489965e0bf0de15"

require linux-aspeed.inc
