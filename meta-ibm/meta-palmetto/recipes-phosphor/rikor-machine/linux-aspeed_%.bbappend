

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://dts-first.patch"

