
OBMC_IMAGE_EXTRA_INSTALL_append_palmetto = " mboxd"

IMAGE_INSTALL += "libgpio"
# IMAGE_INSTALL += "liblog"
IMAGE_INSTALL += "lighttpd"
IMAGE_INSTALL += "rikcgi"
IMAGE_INSTALL += "rikgpio"
IMAGE_INSTALL += "rikbtnd"
IMAGE_INSTALL += "rikcgi"
IMAGE_INSTALL += "rikcgi-login"
IMAGE_INSTALL += "rikor-fru"


