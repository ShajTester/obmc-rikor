EXTRA_OECMAKE_df-openpower += "-DBMCWEB_ENABLE_REDFISH_DBUS_LOG_ENTRIES=ON"
EXTRA_OECMAKE += "-DCMAKE_BUILD_TYPE=Debug"
